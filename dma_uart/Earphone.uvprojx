# Keil uVision project Earphone.uvprojx, settings and files
target Earphone (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC822M101JHI33 NXP
  pack: Keil.LPC800_DFP.1.2.0
  cpu: IROM(0x00000000,0x4000) IRAM(0x10000000,0x1000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: periph_dma_uart +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: ..\board_common;..\chip_8xx;..\chip_common;..\CMSIS\Include;..\config_82x;..\..\Earphone-Code0.2
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group dma_uart
    ../: keil_startup_lpc82x.s dma_uart.c manchester.c sysinit.c
  group board
    ../: board.c board_sysinit.c
  group chip_8xx
    ../chip_8xx/: clock_8xx.c dma_8xx.c gpio_8xx.c iocon_8xx.c syscon_8xx.c sysinit_8xx.c uart_8xx.c acmp_8xx.c swm_8xx.c chip_8xx.c irc_8xx.c
    ../chip_common/: ring_buffer.c
